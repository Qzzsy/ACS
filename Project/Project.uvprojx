# Keil uVision project Project.uvprojx, settings and files
target 客户端 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: KHD_2 +hex
  BeforeMake: VerManage.exe
  c flags: Optim=1 OneElfS=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx,__FPU_PRESENT = 1,__FPU_USED=1,ARM_MATH_CM4,__CC_ARM,HSE_VALUE=8000000
  c include: ..\Bsp\Libraries\inc;..\Bsp\Libraries\src;..\Bsp\Libraries\System;..\Bsp\Libraries\CMSIS\Device\Include;..\Bsp\Libraries\CMSIS\Device\Startup;..\Bsp\Libraries\CMSIS\Include;..\Bsp\Applications;..\RT-Thread\src;..\RT-Thread\include;..\RT-Thread\libcpu\arm\cortex-m4;..\RT-Thread\libcpu\arm\common;..\RT-Thread\drivers;..\RT-Thread\rtConfig;..\RT-Thread\components\drivers\include;..\RT-Thread\components\drivers\src;..\RT-Thread\components\drivers\misc;..\RT-Thread\components\finsh;..\RT-Thread\components\drivers\serial;..\RT-Thread\components\drivers\spi;..\RT-Thread\components\gui\include\rtgui;..\RT-Thread\components\CMSIS\Include;..\Project;..\Bsp\System\delay;..\Bsp\Drivers\iic;..\Bsp\Drivers\lcd_fsmc;..\Bsp\Drivers\sram;..\Bsp\Drivers\spi_hard;..\Bsp\Peripheral\touch;..\Bsp\Peripheral\touch;..\Bsp\Peripheral\flash;..\Bsp\Peripheral\RFID;..\STemWin\Config;..\STemWin\inc;..\STemWin\Lib;..\STemWin\OS;..\Applications;..\APP\key;..\APP\LCD;..\APP;..\APP\RC522;..\APP\LED;..\APP\touch;..\APP\GUIDemo;..\Bsp\Drivers\PWM;..\APP\mycryp;..\Bsp\Libraries\stm32_cryp\inc;..\APP\CPU_Usage;..\APP\mem_usage;..\APP\pysearch;..\Bsp\Peripheral\SP3485;..\APP\sp3485;..\Bsp\System\QUEUE;..\APP\post_time;..\Bsp\Peripheral\Fingerprint;..\APP\fingerprint;..\APP\Huffman;..\APP\LCD_TEST;..\Applications;..\lvgl-gui\lv_my_dev;..\lvgl-gui;..\lvgl-gui\lv_examples\lv_apps\demo;..\APP\timer_lvgl_tick;..\SystemView\Src;..\SystemView\Sample\RTThread;..\SystemView\Config;..\SystemView;..\lvgl-gui\lv_examples\lv_apps\benchmark;..\Bsp\Drivers\tim;..\..\Cliet;..\SystemView\Src;..\SystemView\Config;..\SystemView\Sample\RTThread;..\lvgl\lv_my_dev;..\lvgl\demo;..\Applications\main_task;..\lvgl\lv_misc\lv_fonts;..\lvgl
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT6: RAM 0x68000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group APP
    ../APP/LED/: LED.c
    ../APP/LCD_TEST/: LCD_TEST.c
  group Applications
    ../Applications/: application.c startup.c
    ../Bsp/System/delay/: delay.c
    ../Bsp/System/QUEUE/: Queue.c
    ../Applications/main_task/: main_task.c
  group Drivers
    ../RT-Thread/drivers/: board.c usart.c
    ../Bsp/Drivers/iic/: iic.c
    ../Bsp/Drivers/spi_hard/: spi_hard.c
    ../Bsp/Drivers/lcd_fsmc/: lcd_fsmc.c
    ../Bsp/Drivers/PWM/: PWM.c
    ../Bsp/Drivers/sram/: sram.c
  group Peripheral
    ../Bsp/Peripheral/touch/: touch_ft6306.c
    ../Bsp/Peripheral/flash/: w25qxx.c
    ../Bsp/Peripheral/RFID/: rfid_rc522.c
    ../Bsp/Peripheral/SP3485/: SP3485.c
    ../Bsp/Peripheral/Fingerprint/: Fingerprint.c
  group Libriries
    ../Bsp/Libraries/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_rtc.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_fsmc.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_syscfg.c stm32f4xx_spi.c stm32f4xx_rng.c stm32f4xx_iwdg.c
  group CMSIS
    ../Bsp/Libraries/CMSIS/Device/Startup/: startup_stm32f40_41xxx.s
    ../Bsp/Libraries/System/: stm32f4xx_it.c system_stm32f4xx.c
  group cryp
    ../Bsp/Libraries/stm32_cryp/binary/MK-ARM/: M4_CryptoFW_RngHW_2_0_6.lib
  group rt_Src_kernel
    ../RT-Thread/src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c module.c object.c scheduler.c signal.c slab.c thread.c timer.c
  group rt_LibCPU_Cortex_m4
    ../RT-Thread/libcpu/arm/common/: backtrace.c div0.c showmem.c
    ../RT-Thread/libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group rt_Finsh
    ../RT-Thread/components/finsh/: cmd.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_token.c finsh_var.c finsh_vm.c msh.c msh_cmd.c msh_file.c shell.c symbol.c
  group rt_Device_driver
    ../RT-Thread/components/drivers/serial/: serial.c
    ../RT-Thread/components/drivers/spi/: spi_core.c spi_dev.c
    ../RT-Thread/components/drivers/src/: completion.c dataqueue.c pipe.c ringbuffer.c waitqueue.c workqueue.c
  group lv_core
    ../lvgl/lv_core/: lv_group.c lv_indev.c lv_obj.c lv_refr.c lv_style.c lv_vdb.c
  group lv_draw
    ../lvgl/lv_draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_rbasic.c lv_draw_rect.c lv_draw_triangle.c lv_draw_vbasic.c
  group lv_misc
    ../lvgl/lv_misc/: lv_anim.c lv_area.c lv_circ.c lv_color.c lv_font.c lv_fs.c lv_ll.c lv_log.c lv_math.c lv_mem.c lv_task.c lv_templ.c lv_txt.c lv_ufs.c
  group lv_objx
    ../lvgl/lv_objx/: lv_arc.c lv_bar.c lv_btn.c lv_btnm.c lv_calendar.c lv_cb.c lv_chart.c lv_cont.c lv_ddlist.c lv_gauge.c lv_img.c lv_imgbtn.c lv_kb.c lv_label.c lv_led.c lv_line.c lv_list.c lv_lmeter.c lv_mbox.c lv_objx_templ.c lv_page.c lv_preload.c lv_roller.c lv_slider.c lv_sw.c lv_ta.c lv_tabview.c lv_win.c
  group lv_themes
    ../lvgl/lv_themes/: lv_theme.c lv_theme_alien.c lv_theme_default.c lv_theme_material.c lv_theme_mono.c lv_theme_nemo.c lv_theme_night.c lv_theme_templ.c lv_theme_zen.c
  group lv_fonts
    ../lvgl/lv_fonts/: lv_font_builtin.c lv_font_dejavu_10.c lv_font_dejavu_10_cyrillic.c lv_font_dejavu_10_latin_sup.c lv_font_dejavu_20.c lv_font_dejavu_20_cyrillic.c lv_font_dejavu_20_latin_sup.c lv_font_dejavu_30.c lv_font_dejavu_30_cyrillic.c lv_font_dejavu_30_latin_sup.c lv_font_dejavu_40.c lv_font_dejavu_40_cyrillic.c lv_font_dejavu_40_latin_sup.c lv_font_monospace_8.c lv_font_symbol_10.c lv_font_symbol_20.c lv_font_symbol_30.c lv_font_symbol_40.c
  group lv_hal
    ../lvgl/lv_hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
  group lv_my_dev
    ../lvgl/lv_my_dev/: tft.c touchpad.c
  group lv_my_demo
    ../lvgl/demo/: demo.c img_bubble_pattern.c
  group font
    ../Applications/font/: WRJZY_20.c WRJZY_40.c HZChar16.c HZCharPEx.c HZChar24.c HZChar32.c HZChar40.c HZChar48.c
